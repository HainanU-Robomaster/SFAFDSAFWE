# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VE ST STM32L475VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; STM32L431xx; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\Projects\rt-thread\include; ..\libraries\HAL_Drivers\drivers; ..\..\..\..\Projects\rt-thread\libcpu\arm\cortex-m4; board\CubeMX_Config\Core\Inc; ..\libraries\STM32L4xx_HAL\CMSIS\Device\ST\STM32L4xx\Include; ..\libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Inc; .; ..\..\..\..\Projects\rt-thread\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\Projects\rt-thread\components\libc\posix\ipc; board; ..\..\..\..\Projects\rt-thread\components\libc\posix\io\epoll; ..\libraries\HAL_Drivers; ..\..\..\..\Projects\rt-thread\components\libc\posix\io\poll; ..\..\..\..\Projects\rt-thread\components\finsh; applications; ..\libraries\HAL_Drivers\drivers\config; ..\..\..\..\Projects\rt-thread\libcpu\arm\common; ..\..\..\..\Projects\rt-thread\components\libc\compilers\common\extension; ..\..\..\..\Projects\rt-thread\components\libc\posix\io\eventfd; ..\libraries\HAL_Drivers\CMSIS\Include; ..\..\..\..\Projects\rt-thread\components\libc\compilers\common\include; ..\..\..\..\Projects\rt-thread\components\drivers\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../../Projects/rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../Projects/rt-thread/components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    ../../../../Projects/rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../Projects/rt-thread/libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../../Projects/rt-thread/components/drivers/core/: device.c
    ../../../../Projects/rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../Projects/rt-thread/components/drivers/misc/: pin.c
    ../../../../Projects/rt-thread/components/drivers/serial/: serial.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    ../libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/iar/: startup_stm32l431xx.s
    board/CubeMX_Config/Core/Src/: stm32l4xx_hal_msp.c
    board/: board.c
  group Finsh
    ../../../../Projects/rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../../Projects/rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    ../libraries/STM32L4xx_HAL/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_cryp.c stm32l4xx_hal_uart.c stm32l4xx_hal_usart.c stm32l4xx_hal_cortex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_pwr.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_crc.c stm32l4xx_hal.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_comp.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_cryp_ex.c
    ../libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
